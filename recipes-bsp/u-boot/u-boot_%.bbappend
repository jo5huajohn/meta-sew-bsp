FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://001-disable-efi.cfg \
"

